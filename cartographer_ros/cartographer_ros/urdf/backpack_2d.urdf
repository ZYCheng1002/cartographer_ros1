Commit message: 增加轮速msg

File: cartographer_ros/cartographer_ros/urdf/backpack_2d.urdf (robot description, URDF)
Before this commit: robot cartographer_backpack_2d, 4 links, 3 joints
Joints:
- joint horizontal_laser_link_joint: origin xyz=0.1007 0 0.0558 -> xyz=0.510 0 0.223 rpy=0 0 0.0123852
